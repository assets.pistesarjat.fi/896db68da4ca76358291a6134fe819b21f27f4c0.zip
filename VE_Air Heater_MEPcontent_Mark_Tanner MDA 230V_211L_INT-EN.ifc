Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-06-10T14:21:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 10 14:21:55 2020 * Host: GVIZITI-RO-DE * Database: C:\Users\gviziti\AppData\Local\Temp\{27061AE7-88F2-4979-BC33-C7781ED02673}\ifc * Database version: 5507 * Database creation date: Wed Jun 10 14:21:53 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Jun 10 14:21:54 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 10 14:21:54 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcAirTerminal: MDA 211L, VE_Air Heater_MEPcontent_Mark_Tanner MDA 230V_INT-EN:MDA 211L:1302685
In: V00
Type - Material: Color RGB 193-193-194, Color RGB 060-060-060, Color RGB 000-000-255
Type - Dimensions - Height: 580 mm; Length: 385 mm; Use Nominal Diameter: yes; Width: 580 mm
Type - Electrical - Voltage: 230 V
Type - Electrical - Loads - Power: 40 W
Type - Identity Data - Article Description: Water-supplied suspended air heater; Article Type: MDA 211L; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Water-supplied suspended air heater; EMCS Version: 3.0; ETIM Article Class: EC011395; Family Version: 11.14; GTIN: 87193336025003; Manufacturer: Mark; Manufacturer Art. No.: 5060250; Manufacturer URL: http://www.markclimate.com/air-heating/water-fed/tanner-mda/; MEPcontent Class: AIR_HEATER; Model: MDA 211L; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Product Line: Mark; Revit Version: 2018; Type Name: MDA 211L; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Mechanical - Flow - Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s
Type - Other - Category: Mechanical Equipment; Distance Between Brackets: 517 mm; Family Name: VE_Air Heater_MEPcontent_Mark_Tanner MDA 230V_INT-EN; Nominal Diameter: 25.4 mm; Outer Diameter: 33.7 mm
Type - Visibility - 1 Blade for Tanner MDA 200: yes; 1 Blade for Tanner MDA 300: no; 1 Blade for Tanner MDA 400: no; 2 Blades for Tanner MDA 100: no; 2 Blades for Tanner MDA 200: no; 2 Blades for Tanner MDA 300: no; 2 Blades for Tanner MDA 400: no; 3 Blades for Tanner MDA 100: no; 3 Blades for Tanner MDA 200: no; 3 Blades for Tanner MDA 300: no; 3 Blades for Tanner MDA 400: no; 4 Blades for Tanner MDA 100: no; 4 Blades for Tanner MDA 200: no; 4 Blades for Tanner MDA 300: no; 4 Blades for Tanner MDA 400: no; Tanner MDA 100: no; Tanner MDA 200: yes; Tanner MDA 300: no; Tanner MDA 400: no
Type - Pset_AirTerminalTypeCommon - Reference: MDA 211L
Pset_ManufacturerTypeInformation - Manufacturer: Mark
Constraints - Offset: 0 mm
Dimensions - Area: 2.42439 m2; Volume: 0.232731 m3
Identity Data - Mark: 4
Mechanical - System Classification: Hydronic Supply,Hydronic Return,Power
Model Properties - Pendant Length: 500 mm; Suspension Console: no
Other - Family: VE_Air Heater_MEPcontent_Mark_Tanner MDA 230V_INT-EN: MDA 211L; Family and Type: VE_Air Heater_MEPcontent_Mark_Tanner MDA 230V_INT-EN: MDA 211L; Hydronic Return Diameter: 25.4 mm; Hydronic Supply Diameter: 25.4 mm; Lenght Pendant Safe: 500 mm; Pendant Visible: yes; Suspension Console Offset: 0 mm; Type: VE_Air Heater_MEPcontent_Mark_Tanner MDA 230V_INT-EN: MDA 211L; Type Id: VE_Air Heater_MEPcontent_Mark_Tanner MDA 230V_INT-EN: MDA 211L; Vertical Offset: 500 mm
Phasing - Phase Created: 3. New Construction
