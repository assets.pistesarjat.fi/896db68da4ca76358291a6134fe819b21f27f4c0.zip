Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-03-03T09:43:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 03 09:43:56 2022 * Host: MBARNA-RO-LE * Database: C:\Users\mBarna\AppData\Local\Temp\{4EEC7690-BA03-469C-8A83-4E01132DDEED}\ifc * Database version: 5507 * Database creation date: Thu Mar 03 09:43:53 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Mar 03 09:43:54 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 03 09:43:54 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcAirTerminal: 541L, VE_Air Heater_MEPcontent_Mark_Tanner MDA 230V_aaaa_INT-EN:541L:1306200
In: F00
Type - Material: Color RGB 193-193-194, Color RGB 060-060-060, Color RGB 000-000-255
Type - Dimensions - Height: 730 mm; Length: 385 mm; Use Nominal Diameter: yes; Width: 1460 mm
Type - Electrical - Voltage: 230 V
Type - Electrical - Loads - Power: 40 W
Type - Identity Data - Article Description: Water-supplied suspended air heater; Article Type: MDA 541L; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Water-supplied suspended air heater; EMCS Version: 4.0; ETIM Article Class: EC011395; Family Version: 11.14; GTIN: 8720246316162; Manufacturer: Mark; Manufacturer Art. No.: 5060473; Manufacturer URL: http://www.markclimate.com/air-heating/water-fed/tanner-mda/; MEPcontent Class: AIR_HEATER; Model: MDA 541L; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Product Line: Mark; Revit Version: 2019; Type Name: 541L; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Mechanical - Flow - Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s
Type - Other - Category: Mechanical Equipment; Connector Lenght: 115 mm; Distance Between Brackets: 1334 mm; Distance From Center: 0 mm; Family Name: VE_Air Heater_MEPcontent_Mark_Tanner MDA 230V_aaaa_INT-EN; Nominal Diameter: 25.4 mm; Outer Diameter: 33.7 mm; Tanner MDA 500 Safe: no
Type - Text - Pipe Type Category: ML570
Type - Visibility - 1 Blade for Tanner MDA 200: no; 1 Blade for Tanner MDA 300: no; 1 Blade for Tanner MDA 400: no; 2 Blades for Tanner MDA 100: no; 2 Blades for Tanner MDA 200: no; 2 Blades for Tanner MDA 300: no; 2 Blades for Tanner MDA 400: no; 3 Blades for Tanner MDA 100: no; 3 Blades for Tanner MDA 200: no; 3 Blades for Tanner MDA 300: no; 3 Blades for Tanner MDA 400: no; 4 Blades for Tanner MDA 100: no; 4 Blades for Tanner MDA 200: no; 4 Blades for Tanner MDA 300: yes; 4 Blades for Tanner MDA 400: no; Tanner MDA 100: no; Tanner MDA 200: no; Tanner MDA 300: yes; Tanner MDA 400: no; Tanner MDA 500: yes
Type - Pset_AirTerminalTypeCommon - Reference: 541L
Pset_ManufacturerTypeInformation - Manufacturer: Mark
Constraints - Offset: 0 mm
Dimensions - Area: 6.30627 m2; Volume: 0.738537 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - System Classification: Hydronic Supply,Hydronic Return,Power
Model Properties - Pendant Length: 500 mm; Suspension Console: no
Other - Family: VE_Air Heater_MEPcontent_Mark_Tanner MDA 230V_aaaa_INT-EN: 541L; Family and Type: VE_Air Heater_MEPcontent_Mark_Tanner MDA 230V_aaaa_INT-EN: 541L; Hydronic Return Diameter: 25.4 mm; Hydronic Supply Diameter: 25.4 mm; Lenght Pendant Safe: 500 mm; Pendant Visible: no; Suspension Console Offset: 0 mm; Tanner MDA 500 Pedant Safe: yes; Type: VE_Air Heater_MEPcontent_Mark_Tanner MDA 230V_aaaa_INT-EN: 541L; Type Id: VE_Air Heater_MEPcontent_Mark_Tanner MDA 230V_aaaa_INT-EN: 541L; Vertical Offset: 500 mm
Phasing - Phase Created: 4. Plan over 10 years
